FILESEXTRAPATHS_prepend_raspberrypi3 := "${THISDIR}/arm:"
FILESEXTRAPATHS_prepend_raspberrypi4 := "${THISDIR}/aarch:"

COMPATIBLE = "${MACHINE}"
