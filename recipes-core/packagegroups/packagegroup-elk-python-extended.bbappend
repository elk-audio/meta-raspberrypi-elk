# RPi specific python packages

RDEPENDS:packagegroup-elk-python-extended += "\
    python3-luma-core \
    python3-luma-oled \
"